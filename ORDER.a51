;ASSENDING ORDER
; BUBBLE SORT 
; 8086 HARDWARE..
MOV CH,05H
L3: MOV CL ,05H
MOV SI , 2000
L2: MOV AL,[SI]
MOV BL,[SI+1]
CMP AL ,BL
JC L1
MOV DL,[SI+1]
XCHG [SI], DL
MOV [SI+1],DL
L1 :INC SI
DEC CL
JNZ L2
CEC CH
JNZ L3
HLT


;DECENDING ORDER
MOV CH, 05H
MOV CL,05H
MOV SI, 2000
MOV AL,[SI]
MOV BL,[SI+1]
CMP AL, BL
JNC 101B
MOV DL,[SI+1]
XCHG [SI], DL
MOV [SI+1] DL
INC SI
DEC CL
JNZ 100A
DEC CH
JNZ 1003
HLT
